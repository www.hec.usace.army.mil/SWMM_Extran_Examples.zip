[TITLE]
;;Project Title/Notes
 The first six EXTRAN 3/4 examples

[OPTIONS]
;;Option             Value
FLOW_UNITS           CFS
INFILTRATION         HORTON
FLOW_ROUTING         DYNWAVE
LINK_OFFSETS         DEPTH
MIN_SLOPE            0
ALLOW_PONDING        NO
SKIP_STEADY_STATE    NO

START_DATE           01/01/1988
START_TIME           00:00:00
REPORT_START_DATE    01/01/1988
REPORT_START_TIME    00:00:00
END_DATE             01/01/1988
END_TIME             06:00:00
SWEEP_START          01/01
SWEEP_END            12/31
DRY_DAYS             0
REPORT_STEP          00:05:00
WET_STEP             00:15:00
DRY_STEP             01:00:00
ROUTING_STEP         0:00:20 
RULE_STEP            00:00:00

INERTIAL_DAMPING     NONE
NORMAL_FLOW_LIMITED  SLOPE
FORCE_MAIN_EQUATION  H-W
VARIABLE_STEP        0.50
LENGTHENING_STEP     0
MIN_SURFAREA         12.566
MAX_TRIALS           0
HEAD_TOLERANCE       0
SYS_FLOW_TOL         5
LAT_FLOW_TOL         5
MINIMUM_STEP         0.5
THREADS              1

[EVAPORATION]
;;Data Source    Parameters
;;-------------- ----------------
CONSTANT         0.6
DRY_ONLY         NO

[JUNCTIONS]
;;Name           Elevation  MaxDepth   InitDepth  SurDepth   Aponded   
;;-------------- ---------- ---------- ---------- ---------- ----------
10309            101.60     9.40       .00        0          0         
10309a           101.60     9.40       .00        0          0         
10309b           101.60     9.40       .00        0          0         
10309c           101.60     9.40       .00        0          0         
10309d           101.60     9.40       .00        0          0         
10309e           101.60     9.40       .00        0          0         
15009            111.50     13.50      .00        0          0         
15009a           111.50     13.50      .00        0          0         
15009b           111.50     13.50      .00        0          0         
15009c           111.50     13.50      .00        0          0         
15009d           111.50     13.50      .00        0          0         
15009e           111.50     13.50      .00        0          0         
16009            102.00     18.00      .00        0          0         
16009a           102.00     18.00      .00        0          0         
16009b           102.00     18.00      .00        0          0         
16009c           102.00     18.00      .00        0          0         
16009d           102.00     18.00      .00        0          0         
16009e           102.00     18.00      .00        0          0         
16109            102.80     22.20      .00        0          0         
16109a           102.80     22.20      .00        0          0         
16109b           102.80     22.20      .00        0          0         
16109c           102.80     22.20      .00        0          0         
16109d           102.80     22.20      .00        0          0         
16109e           102.80     22.20      .00        0          0         
;JUNCTION DATA
80408            124.60     13.40      .00        0          0         
;2nd network or extran example 2
80408a           124.60     13.40      .00        0          0         
;3rd network or extran example 3
80408b           124.60     13.40      .00        0          0         
;4th network or extran example 4
80408c           124.60     13.40      .00        0          0         
;5th network or extran example 5
80408d           124.60     13.40      .00        0          0         
;6th network or extran example 7
80408e           124.60     13.40      .00        0          0         
80608            118.30     16.70      .00        0          0         
80608a           118.30     16.70      .00        0          0         
80608b           118.30     16.70      .00        0          0         
80608c           118.30     16.70      .00        0          0         
80608d           118.30     16.70      .00        0          0         
80608e           118.30     16.70      .00        0          0         
81009            128.20     8.80       .00        0          0         
81009a           128.20     8.80       .00        0          0         
81009b           128.20     8.80       .00        0          0         
81009c           128.20     8.80       .00        0          0         
81009d           128.20     8.80       .00        0          0         
81009e           128.20     8.80       .00        0          0         
81309            117.50     12.50      .00        0          0         
81309a           117.50     12.50      .00        0          0         
81309b           117.50     12.50      .00        0          0         
81309c           117.50     12.50      .00        0          0         
81309d           117.50     12.50      .00        0          0         
81309e           117.50     12.50      .00        0          0         
82308d           112.3      42.70      .00        0          0         
82309            112.30     42.70      .00        0          0         
82309a           112.30     42.70      .00        0          0         
82309b           112.30     42.70      .00        0          0         
82309c           112.30     42.70      .00        0          0         
82309e           112.30     42.70      .00        0          0         

[OUTFALLS]
;;Name           Elevation  Type       Stage Data       Gated    Route To        
;;-------------- ---------- ---------- ---------------- -------- ----------------
;*
10208            89.9       FREE                        NO                       
10208b           89.9       FREE                        NO                       
10208c           89.9       FREE                        NO                       
10208d           89.9       FREE                        NO                       
10208e           89.9       FREE                        NO                       
10208a           89.9       FIXED      94.4             YES                      

[STORAGE]
;;Name           Elev.    MaxDepth   InitDepth  Shape      Curve Type/Params            SurDepth  Fevap    Psi      Ksat     IMD     
;;-------------- -------- ---------- ----------- ---------- ---------------------------- --------- --------          -------- --------
;*   STORAGE JUNCTION AT JUNCTION 82309d for the 5th network
82309d           114.5    42.7       0.0        FUNCTIONAL 800.0      0          0        0         0       

[CONDUITS]
;;Name           From Node        To Node          Length     Roughness  InOffset   OutOffset  InitFlow   MaxFlow   
;;-------------- ---------------- ---------------- ---------- ---------- ---------- ---------- ---------- ----------
;CONDUIT DATA - base extran example or example 1
8040             80408            80608            1800.0     0.015      0.0        0.0        0.0        0         
8060             80608            82309            2075.0     0.015      0.0        2.2        0.0        0         
8100             81009            81309            5100.0     0.015      0.0        0.0        0.0        0         
8130             81309            15009            3500.0     0.015      0.0        0.0        0.0        0         
1030             10309            10208            4500.0     0.016      0.0        0.0        0.0        0         
1570             15009            16009            5000.0     0.0154     0.0        0.0        0.0        0         
1600             16009            16109            500.0      0.015      0.0        0.0        0.0        0         
1630             16009            10309            300.0      0.015      0.0        0.0        0.0        0         
1602             82309            16109            5000.0     0.034      0.0        0.0        0.0        0         
;2nd network or extran example 2
8040a            80408a           80608a           1800.0     0.015      0.0        0.0        0.0        0         
8060a            80608a           82309a           2075.0     0.015      0.0        2.2        0.0        0         
8100a            81009a           81309a           5100.0     0.015      0.0        0.0        0.0        0         
8130a            81309a           15009a           3500.0     0.015      0.0        0.0        0.0        0         
1030a            10309a           10208a           4500.0     0.016      0.0        0.0        0.0        0         
1570a            15009a           16009a           5000.0     0.0154     0.0        0.0        0.0        0         
1600a            16009a           16109a           500.0      0.015      0.0        0.0        0.0        0         
1630a            16009a           10309a           300.0      0.015      0.0        0.0        0.0        0         
1602a            82309a           16109a           5000.0     0.034      0.0        0.0        0.0        0         
;3rd network or extran example 3
8040b            80408b           80608b           1800.0     0.015      0.0        0.0        0.0        0         
8060b            80608b           82309b           2075.0     0.015      0.0        2.2        0.0        0         
8100b            81009b           81309b           5100.0     0.015      0.0        0.0        0.0        0         
8130b            81309b           15009b           3500.0     0.015      0.0        0.0        0.0        0         
1030b            10309b           10208b           4500.0     0.016      0.0        0.0        0.0        0         
1570b            15009b           16009b           5000.0     0.0154     0.0        0.0        0.0        0         
1600b            16009b           16109b           500.0      0.015      0.0        0.0        0.0        0         
1630b            16009b           10309b           300.0      0.015      0.0        0.0        0.0        0         
1602b            82309b           16109b           5000.0     0.034      0.0        0.0        0.0        0         
;4th network or extran example 4
8040c            80408c           80608c           1800.0     0.015      0.0        0.0        0.0        0         
8060c            80608c           82309c           2075.0     0.015      0.0        2.2        0.0        0         
8100c            81009c           81309c           5100.0     0.015      0.0        0.0        0.0        0         
8130c            81309c           15009c           3500.0     0.015      0.0        0.0        0.0        0         
1030c            10309c           10208c           4500.0     0.016      0.0        0.0        0.0        0         
1570c            15009c           16009c           5000.0     0.0154     0.0        0.0        0.0        0         
1600c            16009c           16109c           500.0      0.015      0.0        0.0        0.0        0         
1630c            16009c           10309c           300.0      0.015      0.0        0.0        0.0        0         
1602c            82309c           16109c           5000.0     0.034      0.0        0.0        0.0        0         
;5th network or extran example 5
8040d            80408d           80608d           1800.0     0.015      0.0        0.0        0.0        0         
8060d            80608d           82309d           2075.0     0.015      0.0        0          0.0        0         
8100d            81009d           81309d           5100.0     0.015      0.0        0.0        0.0        0         
8130d            81309d           15009d           3500.0     0.015      0.0        0.0        0.0        0         
1030d            10309d           10208d           4500.0     0.016      0.0        0.0        0.0        0         
1570d            15009d           16009d           5000.0     0.0154     0.0        0.0        0.0        0         
1600d            16009d           16109d           500.0      0.015      0.0        0.0        0.0        0         
1630d            16009d           10309d           300.0      0.015      0.0        0.0        0.0        0         
1602d            82308d           16109d           5000.0     0.034      0.0        0.0        0.0        0         
;6th network or extran example 7
8040e            80408e           80608e           1800.0     0.015      0.0        0.0        0.0        0         
8060e            80608e           82309e           2075.0     0.015      0.0        2.2        0.0        0         
8100e            81009e           81309e           5100.0     0.015      0.0        0.0        0.0        0         
8130e            81309e           15009e           3500.0     0.015      0.0        0.0        0.0        0         
1030e            10309e           10208e           4500.0     0.016      0.0        0.0        0.0        0         
1570e            15009e           16009e           5000.0     0.0154     0.0        0.0        0.0        0         
1600e            16009e           16109e           500.0      0.015      0.0        0.0        0.0        0         
1630e            16009e           10309e           300.0      0.015      0.0        0.0        0.0        0         
1602e            82309e           16109e           5000.0     0.034      0.0        0.0        0.0        0         

[PUMPS]
;;Name           From Node        To Node          Pump Curve       Status   Sartup Shutoff 
;;-------------- ---------------- ---------------- ---------------- ------ -------- --------
;* IPTYP NJUNC NJUNC PRATE1  - PRATE3  VRATE1 VRATE2 - for example 7
PUMP1@82309e-15009e 82309e           15009e           PUMPCURVEforPUMP1@82309e-15009e ON       0        0       

[ORIFICES]
;;Name           From Node        To Node          Type         Offset     Qcoeff     Gated    CloseTime 
;;-------------- ---------------- ---------------- ------------ ---------- ---------- -------- ----------
;*   SUMP ORIFICE AT JUNCTION 82309b for the 3rd network
OR1@82309b-15009b 82309b           15009b           BOTTOM       0.0        0.85       NO       0         
OR1@82309d-82308d 82309d           82308d           SIDE         0          0.85       NO       0         

[WEIRS]
;;Name           From Node        To Node          Type         CrestHt    Qcoeff     Gated    EndCon   EndCoeff   Surcharge  RoadWidth  RoadSurf   Coeff. Curve
;;-------------- ---------------- ---------------- ------------ ---------- ---------- -------- -------- ---------- ---------- ---------- ---------- ----------------
;*   TRANVERSE WEIR AT JUNCTION 82309c for the 4th network
WEIR1@82309c-15009c 82309c           15009c           TRANSVERSE   3.0        3.3        NO       0        0          YES       

[XSECTIONS]
;;Link           Shape        Geom1            Geom2      Geom3      Geom4      Barrels    Culvert   
;;-------------- ------------ ---------------- ---------- ---------- ---------- ---------- ----------
8040             CIRCULAR     4.0              0.0        0.0        0.0        1.0                  
8060             CIRCULAR     4.0              0.0        0.0        0.0        1.0                  
8100             CIRCULAR     4.5              0.0        0.0        0.0        1.0                  
8130             CIRCULAR     4.5              0.0        0.0        0.0        1.0                  
1030             TRIANGULAR   9.0              54.0       0          0          1.0                  
1570             CIRCULAR     5.5              0.0        0.0        0.0        1.0                  
1600             CIRCULAR     6.0              0.0        0.0        0.0        1.0                  
1630             TRIANGULAR   9.0              54.0       0          0          1.0                  
1602             CIRCULAR     5.0              0.0        0.0        0.0        1.0                  
8040a            CIRCULAR     4.0              0.0        0.0        0.0        1.0                  
8060a            CIRCULAR     4.0              0.0        0.0        0.0        1.0                  
8100a            CIRCULAR     4.5              0.0        0.0        0.0        1.0                  
8130a            CIRCULAR     4.5              0.0        0.0        0.0        1.0                  
1030a            TRIANGULAR   9.0              54.0       0          0          1.0                  
1570a            CIRCULAR     5.5              0.0        0.0        0.0        1.0                  
1600a            CIRCULAR     6.0              0.0        0.0        0.0        1.0                  
1630a            TRIANGULAR   9.0              54.0       0          0          1.0                  
1602a            CIRCULAR     5.0              0.0        0.0        0.0        1.0                  
8040b            CIRCULAR     4.0              0.0        0.0        0.0        1.0                  
8060b            CIRCULAR     4.0              0.0        0.0        0.0        1.0                  
8100b            CIRCULAR     4.5              0.0        0.0        0.0        1.0                  
8130b            CIRCULAR     4.5              0.0        0.0        0.0        1.0                  
1030b            TRIANGULAR   9.0              54.0       0          0          1.0                  
1570b            CIRCULAR     5.5              0.0        0.0        0.0        1.0                  
1600b            CIRCULAR     6.0              0.0        0.0        0.0        1.0                  
1630b            TRIANGULAR   9.0              54.0       0          0          1.0                  
1602b            CIRCULAR     5.0              0.0        0.0        0.0        1.0                  
8040c            CIRCULAR     4.0              0.0        0.0        0.0        1.0                  
8060c            CIRCULAR     4.0              0.0        0.0        0.0        1.0                  
8100c            CIRCULAR     4.5              0.0        0.0        0.0        1.0                  
8130c            CIRCULAR     4.5              0.0        0.0        0.0        1.0                  
1030c            TRIANGULAR   9.0              54.0       0          0          1.0                  
1570c            CIRCULAR     5.5              0.0        0.0        0.0        1.0                  
1600c            CIRCULAR     6.0              0.0        0.0        0.0        1.0                  
1630c            TRIANGULAR   9.0              54.0       0          0          1.0                  
1602c            CIRCULAR     5.0              0.0        0.0        0.0        1.0                  
8040d            CIRCULAR     4.0              0.0        0.0        0.0        1.0                  
8060d            CIRCULAR     4.0              0.0        0.0        0.0        1.0                  
8100d            CIRCULAR     4.5              0.0        0.0        0.0        1.0                  
8130d            CIRCULAR     4.5              0.0        0.0        0.0        1.0                  
1030d            TRIANGULAR   9.0              54.0       0          0          1.0                  
1570d            CIRCULAR     5.5              0.0        0.0        0.0        1.0                  
1600d            CIRCULAR     6.0              0.0        0.0        0.0        1.0                  
1630d            TRIANGULAR   9.0              54.0       0          0          1.0                  
1602d            CIRCULAR     5.0              0.0        0.0        0.0        1.0                  
8040e            CIRCULAR     4.0              0.0        0.0        0.0        1.0                  
8060e            CIRCULAR     4.0              0.0        0.0        0.0        1.0                  
8100e            CIRCULAR     4.5              0.0        0.0        0.0        1.0                  
8130e            CIRCULAR     4.5              0.0        0.0        0.0        1.0                  
1030e            TRIANGULAR   9.0              54.0       0          0          1.0                  
1570e            CIRCULAR     5.5              0.0        0.0        0.0        1.0                  
1600e            CIRCULAR     6.0              0.0        0.0        0.0        1.0                  
1630e            TRIANGULAR   9.0              54.0       0          0          1.0                  
1602e            CIRCULAR     5.0              0.0        0.0        0.0        1.0                  
OR1@82309b-15009b CIRCULAR     2                0          0          0
OR1@82309d-82308d CIRCULAR     2                0          0          0
WEIR1@82309c-15009c RECT_OPEN    6                3          0          0         

[CONTROLS]

RULE WetWel1_1  
IF NODE 82309e HEAD > 100
THEN PUMP PUMP1@82309e-15009e STATUS = ON
PRIORITY 1






[INFLOWS]
;;Node           Constituent      Time Series      Type     Mfactor  Sfactor  Baseline Pattern
;;-------------- ---------------- ---------------- -------- -------- -------- -------- --------
80408            FLOW             INFLOW@80408     FLOW     1.0      1.0              
80408a           FLOW             INFLOW@80408a    FLOW     1.0      1.0              
80408b           FLOW             INFLOW@80408b    FLOW     1.0      1.0              
80408c           FLOW             INFLOW@80408c    FLOW     1.0      1.0              
80408d           FLOW             INFLOW@80408d    FLOW     1.0      1.0              
80408e           FLOW             INFLOW@80408e    FLOW     1.0      0.5              
81009            FLOW             INFLOW@81009     FLOW     1.0      1.0              
81009a           FLOW             INFLOW@81009a    FLOW     1.0      1.0              
81009b           FLOW             INFLOW@81009b    FLOW     1.0      1.0              
81009c           FLOW             INFLOW@81009c    FLOW     1.0      1.0              
81009d           FLOW             INFLOW@81009d    FLOW     1.0      1.0              
81009e           FLOW             INFLOW@81009e    FLOW     1.0      1.0              
82309            FLOW             INFLOW@82309     FLOW     1.0      1.0              
82309a           FLOW             INFLOW@82309a    FLOW     1.0      1.0              
82309b           FLOW             INFLOW@82309b    FLOW     1.0      1.0              
82309c           FLOW             INFLOW@82309c    FLOW     1.0      1.0              
82309e           FLOW             INFLOW@82309e    FLOW     1.0      1.0              
82309d           FLOW             INFLOW@82309d    FLOW     1.0      1.0              

[DWF]
;;Node           Constituent      Baseline   Patterns  
;;-------------- ---------------- ---------- ----------
16109            FLOW             0.0       

[CURVES]
;;Name           Type       X-Value    Y-Value   
;;-------------- ---------- ---------- ----------
PUMPCURVEforPUMP1@82309e-15009e PUMP2      8.0        5.0       
PUMPCURVEforPUMP1@82309e-15009e            25.0       10.0      
PUMPCURVEforPUMP1@82309e-15009e            42.7       20.0      

[TIMESERIES]
;;Name           Date       Time       Value     
;;-------------- ---------- ---------- ----------
INFLOW@82309     01/01/1988 00:00      0.00000   
INFLOW@82309                00:15      40.00000  
INFLOW@82309                03:00      40.00000  
INFLOW@82309                03:15      0.00000   
INFLOW@82309                12:00      0.00000   
;
INFLOW@80408     01/01/1988 00:00      0.00000   
INFLOW@80408                00:15      45.00000  
INFLOW@80408                03:00      45.00000  
INFLOW@80408                03:15      0.00000   
INFLOW@80408                12:00      0.00000   
;
INFLOW@81009     01/01/1988 00:00      0.00000   
INFLOW@81009                00:15      50.00000  
INFLOW@81009                03:00      50.00000  
INFLOW@81009                03:15      0.00000   
INFLOW@81009                12:00      0.00000   
;
INFLOW@82309a    01/01/1988 00:00      0.00000   
INFLOW@82309a               00:15      40.00000  
INFLOW@82309a               03:00      40.00000  
INFLOW@82309a               03:15      0.00000   
INFLOW@82309a               12:00      0.00000   
;
INFLOW@80408a    01/01/1988 00:00      0.00000   
INFLOW@80408a               00:15      45.00000  
INFLOW@80408a               03:00      45.00000  
INFLOW@80408a               03:15      0.00000   
INFLOW@80408a               12:00      0.00000   
;
INFLOW@81009a    01/01/1988 00:00      0.00000   
INFLOW@81009a               00:15      50.00000  
INFLOW@81009a               03:00      50.00000  
INFLOW@81009a               03:15      0.00000   
INFLOW@81009a               12:00      0.00000   
;
INFLOW@82309b    01/01/1988 00:00      0.00000   
INFLOW@82309b               00:15      40.00000  
INFLOW@82309b               03:00      40.00000  
INFLOW@82309b               03:15      0.00000   
INFLOW@82309b               12:00      0.00000   
;
INFLOW@80408b    01/01/1988 00:00      0.00000   
INFLOW@80408b               00:15      45.00000  
INFLOW@80408b               03:00      45.00000  
INFLOW@80408b               03:15      0.00000   
INFLOW@80408b               12:00      0.00000   
;
INFLOW@81009b    01/01/1988 00:00      0.00000   
INFLOW@81009b               00:15      50.00000  
INFLOW@81009b               03:00      50.00000  
INFLOW@81009b               03:15      0.00000   
INFLOW@81009b               12:00      0.00000   
;
INFLOW@82309c    01/01/1988 00:00      0.00000   
INFLOW@82309c               00:15      40.00000  
INFLOW@82309c               03:00      40.00000  
INFLOW@82309c               03:15      0.00000   
INFLOW@82309c               12:00      0.00000   
;
INFLOW@80408c    01/01/1988 00:00      0.00000   
INFLOW@80408c               00:15      45.00000  
INFLOW@80408c               03:00      45.00000  
INFLOW@80408c               03:15      0.00000   
INFLOW@80408c               12:00      0.00000   
;
INFLOW@81009c    01/01/1988 00:00      0.00000   
INFLOW@81009c               00:15      50.00000  
INFLOW@81009c               03:00      50.00000  
INFLOW@81009c               03:15      0.00000   
INFLOW@81009c               12:00      0.00000   
;
INFLOW@82309d    01/01/1988 00:00      0.00000   
INFLOW@82309d               00:15      40.00000  
INFLOW@82309d               03:00      40.00000  
INFLOW@82309d               03:15      0.00000   
INFLOW@82309d               12:00      0.00000   
;
INFLOW@80408d    01/01/1988 00:00      0.00000   
INFLOW@80408d               00:15      45.00000  
INFLOW@80408d               03:00      45.00000  
INFLOW@80408d               03:15      0.00000   
INFLOW@80408d               12:00      0.00000   
;
INFLOW@81009d    01/01/1988 00:00      0.00000   
INFLOW@81009d               00:15      50.00000  
INFLOW@81009d               03:00      50.00000  
INFLOW@81009d               03:15      0.00000   
INFLOW@81009d               12:00      0.00000   
;
INFLOW@82309e    01/01/1988 00:00      0.00000   
INFLOW@82309e               00:15      40.00000  
INFLOW@82309e               03:00      40.00000  
INFLOW@82309e               03:15      0.00000   
INFLOW@82309e               12:00      0.00000   
;
INFLOW@80408e    01/01/1988 00:00      0.00000   
INFLOW@80408e               00:15      45.00000  
INFLOW@80408e               03:00      45.00000  
INFLOW@80408e               03:15      0.00000   
INFLOW@80408e               12:00      0.00000   
;
INFLOW@81009e    01/01/1988 00:00      0.00000   
INFLOW@81009e               00:15      50.00000  
INFLOW@81009e               03:00      50.00000  
INFLOW@81009e               03:15      0.00000   
INFLOW@81009e               12:00      0.00000   

[REPORT]
;;Reporting Options
CONTROLS   YES
SUBCATCHMENTS ALL
NODES ALL
LINKS ALL

[TAGS]
Node       10309            10309           
Node       10309a           10309a          
Node       10309b           10309b          
Node       10309c           10309c          
Node       10309d           10309d          
Node       10309e           10309e          
Node       15009            15009           
Node       15009a           15009a          
Node       15009b           15009b          
Node       15009c           15009c          
Node       15009d           15009d          
Node       15009e           15009e          
Node       16009            16009           
Node       16009a           16009a          
Node       16009b           16009b          
Node       16009c           16009c          
Node       16009d           16009d          
Node       16009e           16009e          
Node       16109            16109           
Node       16109a           16109a          
Node       16109b           16109b          
Node       16109c           16109c          
Node       16109d           16109d          
Node       16109e           16109e          
Node       80408            80408           
Node       80408a           80408a          
Node       80408b           80408b          
Node       80408c           80408c          
Node       80408d           80408d          
Node       80408e           80408e          
Node       80608            80608           
Node       80608a           80608a          
Node       80608b           80608b          
Node       80608c           80608c          
Node       80608d           80608d          
Node       80608e           80608e          
Node       81009            81009           
Node       81009a           81009a          
Node       81009b           81009b          
Node       81009c           81009c          
Node       81009d           81009d          
Node       81009e           81009e          
Node       81309            81309           
Node       81309a           81309a          
Node       81309b           81309b          
Node       81309c           81309c          
Node       81309d           81309d          
Node       81309e           81309e          
Node       82308d           82308d          
Node       82309            82309           
Node       82309a           82309a          
Node       82309b           82309b          
Node       82309c           82309c          
Node       82309e           82309e          
Node       10208            10208           
Node       10208b           10208b          
Node       10208c           10208c          
Node       10208d           10208d          
Node       10208e           10208e          
Node       10208a           10208a          
Node       82309d           82309d          
Link       8040             8040            
Link       8060             8060            
Link       8100             8100            
Link       8130             8130            
Link       1030             1030            
Link       1570             1570            
Link       1600             1600            
Link       1630             1630            
Link       1602             1602            
Link       8040a            8040a           
Link       8060a            8060a           
Link       8100a            8100a           
Link       8130a            8130a           
Link       1030a            1030a           
Link       1570a            1570a           
Link       1600a            1600a           
Link       1630a            1630a           
Link       1602a            1602a           
Link       8040b            8040b           
Link       8060b            8060b           
Link       8100b            8100b           
Link       8130b            8130b           
Link       1030b            1030b           
Link       1570b            1570b           
Link       1600b            1600b           
Link       1630b            1630b           
Link       1602b            1602b           
Link       8040c            8040c           
Link       8060c            8060c           
Link       8100c            8100c           
Link       8130c            8130c           
Link       1030c            1030c           
Link       1570c            1570c           
Link       1600c            1600c           
Link       1630c            1630c           
Link       1602c            1602c           
Link       8040d            8040d           
Link       8060d            8060d           
Link       8100d            8100d           
Link       8130d            8130d           
Link       1030d            1030d           
Link       1570d            1570d           
Link       1600d            1600d           
Link       1630d            1630d           
Link       1602d            1602d           
Link       8040e            8040e           
Link       8060e            8060e           
Link       8100e            8100e           
Link       8130e            8130e           
Link       1030e            1030e           
Link       1570e            1570e           
Link       1600e            1600e           
Link       1630e            1630e           
Link       1602e            1602e           

[MAP]
DIMENSIONS -1663.687 1565.261 22200.527 20392.630
Units      None

[COORDINATES]
;;Node           X-Coord            Y-Coord           
;;-------------- ------------------ ------------------
10309            389.470            2421.050          
10309a           389.470            8421.050          
10309b           389.470            14421.050         
10309c           11389.470          14421.050         
10309d           11389.470          8421.050          
10309e           11389.470          2421.050          
15009            4978.950           2421.050          
15009a           4978.950           8421.050          
15009b           4978.950           14421.050         
15009c           15978.950          14421.050         
15009d           15978.950          8421.050          
15009e           15978.950          2421.050          
16009            2494.740           2421.050          
16009a           2494.740           8421.050          
16009b           2494.740           14421.050         
16009c           13494.740          14421.050         
16009d           13494.740          8421.050          
16009e           13494.740          2421.050          
16109            2494.740           7536.840          
16109a           2494.740           13536.840         
16109b           2494.740           19536.840         
16109c           13494.740          19536.840         
16109d           13494.740          13536.840         
16109e           13494.740          7536.840          
80408            10115.790          7536.840          
80408a           10115.790          13536.840         
80408b           10115.790          19536.840         
80408c           21115.790          19536.840         
80408d           21115.790          13536.840         
80408e           21115.790          7536.840          
80608            7463.160           7536.840          
80608a           7463.160           13536.840         
80608b           7463.160           19536.840         
80608c           18463.160          19536.840         
80608d           18463.160          13536.840         
80608e           18463.160          7536.840          
81009            9989.470           2421.050          
81009a           9989.470           8421.050          
81009b           9989.470           14421.050         
81009c           20989.470          14421.050         
81009d           20989.470          8421.050          
81009e           20989.470          2421.050          
81309            7568.420           2421.050          
81309a           7568.420           8421.050          
81309b           7568.420           14421.050         
81309c           18568.420          14421.050         
81309d           18568.420          8421.050          
81309e           18568.420          2421.050          
82308d           14957.890          13536.840         
82309            4957.890           7536.840          
82309a           4957.890           13536.840         
82309b           4957.890           19536.840         
82309c           15957.890          19536.840         
82309e           15957.890          7536.840          
10208            -578.950           4947.370          
10208b           -578.950           16947.370         
10208c           10420.950          16947.370         
10208d           10420.950          10947.370         
10208e           10420.950          4947.370          
10208a           -578.950           10947.370         
82309d           15957.890          13536.840         

[VERTICES]
;;Link           X-Coord            Y-Coord           
;;-------------- ------------------ ------------------

[Polygons]
;;Storage Node   X-Coord            Y-Coord           
;;-------------- ------------------ ------------------
82309d           15957.890          13536.840         

[LABELS]
;;X-Coord          Y-Coord            Label           
7150.770           5209.268           "#1" "" "Arial" 10 0 0
6948.325           11444.569          "#2" "" "Arial" 10 0 0
6664.902           17436.936          "#3" "" "Arial" 10 0 0
18568.658          17679.869          "#4" "" "Arial" 10 0 0
18568.658          11444.569          "#5" "" "Arial" 10 0 0
18690.125          5492.691           "#6" "" "Arial" 10 0 0
7150.770           5209.268           "#1" "" "Arial" 10 0 0
6948.325           11444.569          "#2" "" "Arial" 10 0 0
6664.902           17436.936          "#3" "" "Arial" 10 0 0
18568.658          17679.869          "#4" "" "Arial" 10 0 0
18568.658          11444.569          "#5" "" "Arial" 10 0 0
18690.125          5492.691           "#6" "" "Arial" 10 0 0

